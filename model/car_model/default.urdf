Commit message: sss

File: model/car_model/default.urdf (robot description, URDF)
Before this commit: robot car, 1 links, 0 joints
Links:
- link ground_link: geometry visual mesh filename=package://hybrid_a_star_zm0612/model/car_model/CAR_original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 scale=0.8 0.8 0.8
